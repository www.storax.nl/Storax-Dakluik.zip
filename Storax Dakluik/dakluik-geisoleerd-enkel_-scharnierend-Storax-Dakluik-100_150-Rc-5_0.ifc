Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 6d8d7c46-6710-4406-92e9-a093631a40e6.ifc
Time: 2026-08-11T10:31:18
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - Dakluik 100/150 Rc 5,0
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 5 m²·k/w
Pset_Data - WUID: AgAAAJlZ2IkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAH-sCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJlZ2IkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAH-sCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 30.44.10; dagmaatlengte: 1500 mm; U-waarde: 0,2 w/m²·k; lengte: 1760 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 5 m²·k/w; garantieperiode: 10 jaar; breedte: 1260 mm; NAA.K.T: samengesteld_product_kozijn; weerstand tegen windbelasting: C5; kleur: RAL 7047; theoretische levensduur: 75; serie: Dakluik; merk: Storax; eenheid: st; type: 100/150; dagmaatbreedte: 1000 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
