Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 06f1ea14-4c16-43f5-b6a2-b51e5647dcfa.ifc
Time: 2026-08-11T09:15:45
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - Dakluik 70/140 Rc 5,0
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 5 m²·k/w
Pset_Data - WUID: AgAAAJlc2IkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAGusCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJlc2IkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAGusCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 30.44.10; dagmaatlengte: 1400 mm; U-waarde: 0,2 w/m²·k; lengte: 1660 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 5 m²·k/w; garantieperiode: 10 jaar; breedte: 960 mm; NAA.K.T: samengesteld_product_kozijn; weerstand tegen windbelasting: C5; kleur: RAL 7047; theoretische levensduur: 75; serie: Dakluik; merk: Storax; eenheid: st; type: 70/140; dagmaatbreedte: 700 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
