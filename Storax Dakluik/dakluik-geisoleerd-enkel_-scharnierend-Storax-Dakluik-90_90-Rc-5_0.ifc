Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 22a5c5a6-b8b5-4248-95a7-12a06786509b.ifc
Time: 2026-08-11T10:29:21
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - Dakluik 90/90 Rc 5,0
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 5 m²·k/w
Pset_Data - WUID: AgAAAJl934kFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAO-wCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJl934kFAAAACOwCAAU4QgAAJVQBAInDAAA06wIAO-wCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 30.44.10; dagmaatlengte: 900 mm; U-waarde: 0,2 w/m²·k; lengte: 1160 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 5 m²·k/w; garantieperiode: 10 jaar; breedte: 1160 mm; NAA.K.T: samengesteld_product_kozijn; weerstand tegen windbelasting: C5; kleur: RAL 7047; theoretische levensduur: 75; serie: Dakluik; merk: Storax; eenheid: st; type: 90/90; dagmaatbreedte: 900 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
