Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: e57bb7fe-04e2-44a8-8b5b-cf0ce2a152aa.ifc
Time: 2026-08-11T10:30:50
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, dakluik geïsoleerd enkel, scharnierend Storax - Dakluik 100/100 Rc 5,0
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 5 m²·k/w
Pset_Data - WUID: AgAAAJmr2YkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIA7eoCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJmr2YkFAAAACOwCAAU4QgAAJVQBAInDAAA06wIA7eoCAAQA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAAcIAQEAAAADAAAA5QcBAQAAAAQAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAADUTwAABUi8AABwPgAARZEAABK9AADcewIAAABCagAABWDfAABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 30.44.10; dagmaatlengte: 1000 mm; U-waarde: 0,2 w/m²·k; lengte: 1260 mm; luchtdoorlatendheid klasse: 4; waterdichtheids klasse: 9A; Rc-waarde: 5 m²·k/w; garantieperiode: 10 jaar; breedte: 1260 mm; NAA.K.T: samengesteld_product_kozijn; weerstand tegen windbelasting: C5; kleur: RAL 7047; theoretische levensduur: 75; serie: Dakluik; merk: Storax; eenheid: st; type: 100/100; dagmaatbreedte: 1000 mm; omranding: aluminium; valbeveiliging: geen; luik: aluminium; trap: geen
